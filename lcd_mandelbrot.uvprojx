# Keil uVision project lcd_mandelbrot.uvprojx, settings and files
target STM32F401RE (6180000::V6.18::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lcd_spi +hex
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=5 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group src
    ./: main.c gpio.c spi.c tools.c dma.c lcd.c mandelbrot.c
software components: CMSIS Driver:I2C:Custom 1.0.0, CMSIS Driver:SPI:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.6.0, Device:Startup 2.6.3
